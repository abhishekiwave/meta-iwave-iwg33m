# Copyright (C) 2020 iWave Systems Technologies

require recipes-bsp/imx-mkimage/imx-mkimage_git.bb

SRC_URI = "git://git-codecommit.ap-south-1.amazonaws.com/v1/repos/imx-mkimage-iWave.git;protocol=ssh;branch=main"
SRCREV = "4309f31cedd6adf92a31e585eb0206d34374970b" 
