# Copyright (C) 2020 iWave Systems Technologies

require recipes-bsp/u-boot/u-boot-imx_2020.04.bb

SRC_URI = "git://git-codecommit.ap-south-1.amazonaws.com/v1/repos/uboot-imx-iWave.git;protocol=ssh;branch=main"
SRCREV  = "fc274bf4c8d25484f95b5aa2016045dd70c2ddd7"
