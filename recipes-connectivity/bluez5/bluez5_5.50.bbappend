FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append_iwg33m = " file://bluetooth_compatibility.patch"
